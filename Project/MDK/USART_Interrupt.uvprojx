# Keil uVision project USART_Interrupt.uvprojx, settings and files
target APM32F051 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: APM32F051C6 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_Interrupt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_EVAL,APM32F051
  c include: ..\..\APM32F0xx_StdPeriphDriver\inc;..\..\Include;..\..\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x200000c0 size 0x2000
  group APM32F0xx_StdPeriphDriver
    ../../APM32F0xx_StdPeriphDriver/src/: apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_misc.c apm32f0xx_gpio.c apm32f0xx_rcm.c apm32f0xx_adc.c apm32f0xx_comp.c apm32f0xx_dac.c apm32f0xx_fmc.c apm32f0xx_syscfg.c apm32f0xx_eint.c
  group Application
    ../../Source/: apm32f0xx_int.c main.c bsp_delay.c
    ../../Source/FUNCTION/: DF_Protocol.c func.c setup.c
  group CMSIS
    ../../Source/: startup_apm32f051.s system_apm32f0xx.c
